# Keil uVision project Russia.uvproj, settings and files
target Target 1 (MCS-51)
  device: DS87C530 Dallas Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(33000000) MODDP2 XRAM(0-0x3FF)
  output: Russia +hex
  c flags: Optimize=9
  group Source Group 1
    ./: STARTUP.A51 main.c driver.h pic.h block.h block.c driver.c
